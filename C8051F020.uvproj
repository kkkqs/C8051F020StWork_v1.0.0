# Keil uVision project C8051F020.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: C8051F020 +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    $TC_ROOT$/../../../Git/C8051F020StWork/user/: main.ASM
  group driver
    $TC_ROOT$/../../../Git/C8051F020StWork/driver/: keyboard.asm LED6.asm
  group bsp
    $TC_ROOT$/../../../Git/C8051F020StWork/bsp/: timer0.asm timer1.asm
  group config
    $TC_ROOT$/../../../Git/C8051F020StWork/: config.inc
  group Task
    $TC_ROOT$/../../../Git/C8051F020StWork/Tasks/: ConfigurationTask.asm RunningTask.asm
